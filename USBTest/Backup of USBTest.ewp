# IAR project Backup of USBTest.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L151C6-A ST STM32L151C6-A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L1XX_MD
  ICCARM.CCIncludePath2: Source\; Libraries\STM32L1xx_StdPeriph_Driver\inc; Libraries\STM32_USB-FS-Device_Driver\inc; Libraries\CMSIS\Device\ST\STM32L1xx\Include; Libraries\CMSIS\Include
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBTest.hex
  ILINK.IlinkOutputFile: USBTest.out
  ILINK.IlinkIcfFile: Settings\stm32l151x6-A.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Library - CMSIS
    Libraries/CMSIS/Device/ST/STM32L1xx/Source/Templates/iar/: startup_stm32l1xx_md.s
  group Library - CMSIS/header
    Libraries/CMSIS/Include/: arm_common_tables.h arm_const_structs.h arm_math.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h core_sc000.h core_sc300.h
    Libraries/CMSIS/Device/ST/STM32L1xx/Include/: stm32l1xx.h system_stm32l1xx.h
  group Library - STD
    Libraries/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_exti.c stm32l1xx_gpio.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_syscfg.c
  group Library - STD/header
    Libraries/STM32L1xx_StdPeriph_Driver/inc/: misc.h stm32l1xx_exti.h stm32l1xx_gpio.h stm32l1xx_pwr.h stm32l1xx_rcc.h stm32l1xx_syscfg.h
  group Library - USB
    Libraries/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group Library - USB/header
    Libraries/STM32_USB-FS-Device_Driver/inc/: usb_core.h usb_def.h usb_init.h usb_int.h usb_lib.h usb_mem.h usb_regs.h usb_sil.h usb_type.h
  group Source
    Source/: gpio.c hw_config.c main.c protocol.c stm32l1xx_it.c system_stm32l1xx.c timer.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group Source/header
    Source/: app.h bsp.h gpio.h hw_config.h main.h protocol.h stm32l1xx_conf.h stm32l1xx_it.h structs.h timer.h usb_conf.h usb_desc.h usb_istr.h usb_prop.h usb_pwr.h
