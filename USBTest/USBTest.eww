<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\USBTest.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>Buil_ALL</name>
      <member>
        <project>iAP2</project>
        <configuration>iAP2</configuration>
      </member>
      <member>
        <project>iAP2</project>
        <configuration>iAP2</configuration>
      </member>
      <member>
        <project>iAP2</project>
        <configuration>iAP2</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


